# Keil uVision project mynfc.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mynfc +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\lcd;.\Public;.\App\keyboard;.\App\mypn532;.\App\UART
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
  group App
    ./App/lcd/: lcd.c lcd.h
    ./App/mypn532/: pn532.c pn532.h
    ./App/UART/: uart.c
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c public.h
